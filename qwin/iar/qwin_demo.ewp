# IAR project qwin_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: qwin_demo.bin
  ILINK.IlinkOutputFile: qwin_demo.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  group CMSIS
    cmsis/: core_cm3.h lm3s_cmsis.h
  group Source
    ../: bsp.h main.c
    ./: bsp_lm3s811.c display96x16x1.c display96x16x1.h lm3s_cmsis.h lm3s_config.h startup_ewarm.c system_lm3s.c system_lm3s.h
